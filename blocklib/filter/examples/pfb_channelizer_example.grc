options:
  parameters:
    author: josh
    generate_options: qt_gui
    id: pfb_channelizer_example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_0
  id: analog_noise_source
  parameters:
    T: complex
    amplitude: '0.1'
    domain: cpu
    seed: '0'
    showports: 'False'
    type: analog.noise_type.gaussian
  states: {}
- name: analog_sig_source_0
  id: analog_sig_source
  parameters:
    T: complex
    ampl: '1.0'
    domain: cpu
    frequency: '10000'
    offset: '0'
    phase: '0'
    sampling_freq: samp_rate
    showports: 'False'
    waveform: analog.waveform_type.cos
  states: {}
- name: analog_sig_source_0_0
  id: analog_sig_source
  parameters:
    T: complex
    ampl: '1.0'
    domain: cpu
    frequency: '1000'
    offset: '0'
    phase: '0'
    sampling_freq: samp_rate
    showports: 'False'
    waveform: analog.waveform_type.cos
  states: {}
- name: filter_pfb_channelizer_0
  id: filter_pfb_channelizer
  parameters:
    T: complex
    domain: cpu
    numchans: '2'
    oversample_rate: '1'
    showports: 'False'
    taps: filterk.firdes.low_pass(1.0, 2.0, 0.45, 0.01)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.kernel import fft as fftk
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.kernel import filter as filterk
  states: {}
- name: math_add_0
  id: math_add
  parameters:
    T: complex
    domain: cpu
    nports: '3'
    showports: 'False'
    vlen: '1'
  states: {}
- name: qtgui_freq_sink_0_0
  id: qtgui_freq_sink
  parameters:
    T: complex
    bw: samp_rate / 2
    domain: cpu
    fc: '0'
    fftsize: '1024'
    name: '"1"'
    nconnections: '1'
    showports: 'False'
    wintype: '5'
  states: {}
- name: qtgui_freq_sink_0_0_0
  id: qtgui_freq_sink
  parameters:
    T: complex
    bw: samp_rate / 2
    domain: cpu
    fc: '0'
    fftsize: '1024'
    name: '"2"'
    nconnections: '1'
    showports: 'False'
    wintype: '5'
  states: {}
- name: qtgui_freq_sink_0_1
  id: qtgui_freq_sink
  parameters:
    T: complex
    bw: samp_rate
    domain: cpu
    fc: '0'
    fftsize: '1024'
    name: '"ALL"'
    nconnections: '1'
    showports: 'False'
    wintype: '5'
  states: {}
- name: streamops_deinterleave_0
  id: streamops_deinterleave
  parameters:
    blocksize: '1'
    domain: cpu
    itemsize: '0'
    nstreams: '2'
    showports: 'False'
  states: {}

connections:
- [analog_noise_source_0, '0', math_add_0, '2']
- [analog_sig_source_0, '0', math_add_0, '1']
- [analog_sig_source_0_0, '0', math_add_0, '0']
- [filter_pfb_channelizer_0, '0', qtgui_freq_sink_0_0, '0']
- [filter_pfb_channelizer_0, '1', qtgui_freq_sink_0_0_0, '0']
- [math_add_0, '0', qtgui_freq_sink_0_1, '0']
- [math_add_0, '0', streamops_deinterleave_0, '0']
- [streamops_deinterleave_0, '0', filter_pfb_channelizer_0, '0']
- [streamops_deinterleave_0, '1', filter_pfb_channelizer_0, '1']

metadata:
  file_format: 1
