options:
  parameters:
    author: josh
    generate_options: qt_gui
    id: alsa_tones
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_0
  id: analog_sig_source
  parameters:
    T: float
    ampl: '0.25'
    domain: cpu
    frequency: '440'
    offset: '0'
    phase: '0'
    sampling_freq: samp_rate
    showports: 'False'
    waveform: analog.waveform_type.cos
  states: {}
- name: analog_sig_source_0_0
  id: analog_sig_source
  parameters:
    T: float
    ampl: '0.25'
    domain: cpu
    frequency: '554.4'
    offset: '0'
    phase: '0'
    sampling_freq: samp_rate
    showports: 'False'
    waveform: analog.waveform_type.cos
  states: {}
- name: audio_alsa_sink_0
  id: audio_alsa_sink
  parameters:
    device_name: '"pulse"'
    domain: cpu
    num_inputs: '1'
    ok_to_block: 'True'
    sampling_rate: samp_rate
    showports: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import analog
  states: {}
- name: math_add_0
  id: math_add
  parameters:
    T: float
    domain: cpu
    nports: '2'
    showports: 'False'
    vlen: '1'
  states: {}

connections:
- [analog_sig_source_0, '0', math_add_0, '1']
- [analog_sig_source_0_0, '0', math_add_0, '0']
- [math_add_0, '0', audio_alsa_sink_0, '0']

metadata:
  file_format: 1
