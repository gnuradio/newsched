options:
  parameters:
    author: josh
    generate_options: qt_gui
    id: ofdm_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_vector_source_0
  id: blocks_vector_source
  parameters:
    T: byte
    data: numpy.random.randint(0, 255, 1000)
    impl: cpu
    repeat: 'True'
    showports: 'False'
    tags: '[]'
    vlen: '1'
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    final_xor: '4294967295'
    impl: cpu
    initial_value: '4294967295'
    poly: '79764919'
    showports: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: pdu_stream_to_pdu_0
  id: pdu_stream_to_pdu
  parameters:
    T: byte
    impl: cpu
    packet_len: '96'
    showports: 'False'
  states: {}

connections:
- [blocks_vector_source_0, '0', pdu_stream_to_pdu_0, '0']
- [pdu_stream_to_pdu_0, pdus, digital_crc_append_0, in]

metadata:
  file_format: 1
