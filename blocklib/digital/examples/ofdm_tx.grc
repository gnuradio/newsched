options:
  parameters:
    author: josh
    generate_options: no_gui
    id: ofdm_tx
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: header_mod
  id: variable
  parameters:
    value: digitalk.constellation_bpsk()
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
    impl: cpu
    msg_work: 'False'
    showports: 'False'
  states: {state: disabled}
- name: blocks_vector_source_0
  id: blocks_vector_source
  parameters:
    T: float
    data: numpy.random.randint(0, 255, 96*10)
    impl: cpu
    msg_work: 'False'
    repeat: 'False'
    showports: 'False'
    tags: '[]'
    vlen: '1'
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    final_xor: '4294967295'
    impl: cpu
    initial_value: '4294967295'
    msg_work: 'False'
    poly: '79764919'
    showports: 'False'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.kernel import digital as digitalk
  states: {}
- name: math_multiply_const_0
  id: math_multiply_const
  parameters:
    T: float
    impl: cpu
    k: '1.0'
    msg_work: 'True'
    showports: 'False'
    vlen: '1'
  states: {}
- name: math_multiply_const_0_0
  id: math_multiply_const
  parameters:
    T: float
    impl: cpu
    k: '1.0'
    msg_work: 'False'
    showports: 'False'
    vlen: '1'
  states: {}
- name: pdu_pdu_to_stream_0
  id: pdu_pdu_to_stream
  parameters:
    T: float
    impl: cpu
    msg_work: 'False'
    showports: 'False'
  states: {}
- name: pdu_stream_to_pdu_0
  id: pdu_stream_to_pdu
  parameters:
    T: float
    impl: cpu
    msg_work: 'False'
    packet_len: '96'
    showports: 'False'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      from matplotlib import pyplot as plt

      plt.plot(fg.snk1.data())
      plt.plot(fg.snk2.data(), 'r:')
      plt.show()
    section: main_after_stop
  states: {}
- name: snk1
  id: blocks_vector_sink
  parameters:
    T: float
    impl: cpu
    msg_work: 'False'
    reserve_items: '1024'
    showports: 'False'
    vlen: '1'
  states: {}
- name: snk2
  id: blocks_vector_sink
  parameters:
    T: float
    impl: cpu
    msg_work: 'False'
    reserve_items: '1024'
    showports: 'False'
    vlen: '1'
  states: {}

connections:
- [blocks_vector_source_0, '0', math_multiply_const_0_0, '0']
- [blocks_vector_source_0, '0', pdu_stream_to_pdu_0, '0']
- [math_multiply_const_0, pdus_out, pdu_pdu_to_stream_0, pdus]
- [math_multiply_const_0_0, '0', snk1, '0']
- [pdu_pdu_to_stream_0, '0', snk2, '0']
- [pdu_stream_to_pdu_0, pdus, math_multiply_const_0, pdus_in]

metadata:
  file_format: 1
