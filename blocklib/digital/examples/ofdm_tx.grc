options:
  parameters:
    author: josh
    generate_options: qt_gui
    id: ofdm_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: header_mod
  id: variable
  parameters:
    value: digitalk.constellation_bpsk()
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
    impl: cpu
    showports: 'False'
  states: {}
- name: blocks_vector_source_0
  id: blocks_vector_source
  parameters:
    T: byte
    data: numpy.random.randint(0, 255, 1000)
    impl: cpu
    repeat: 'True'
    showports: 'False'
    tags: '[]'
    vlen: '1'
  states: {}
- name: digital_chunks_to_symbols_0
  id: digital_chunks_to_symbols
  parameters:
    D: '1'
    IN_T: byte
    OUT_T: complex
    impl: cpu
    msg_work: 'True'
    showports: 'False'
    symbol_table: header_mod.points()
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    final_xor: '4294967295'
    impl: cpu
    initial_value: '4294967295'
    poly: '79764919'
    showports: 'False'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.kernel import digital as digitalk
  states: {}
- name: pdu_stream_to_pdu_0
  id: pdu_stream_to_pdu
  parameters:
    T: byte
    impl: cpu
    packet_len: '96'
    showports: 'False'
  states: {}

connections:
- [blocks_vector_source_0, '0', pdu_stream_to_pdu_0, '0']
- [digital_chunks_to_symbols_0, pdus_out, blocks_message_debug_0, store]
- [pdu_stream_to_pdu_0, pdus, digital_chunks_to_symbols_0, pdus_in]

metadata:
  file_format: 1
